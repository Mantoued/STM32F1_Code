# Keil uVision project STM32.uvprojx, settings and files
target Key (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\0_Libraries\CMSIS;..\..\0_Libraries\inc;..\Bsp;..\Middle;..\App;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../../0_Libraries/CMSIS/: startup_stm32f10x_hd.s
  group CMSIS
    ../../0_Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group Library
    ../../0_Libraries/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_spi.c
  group Bsp
    ../Bsp/: Bsp_Gpio.c Bsp_All.c Bsp_Tim.c Bsp_Key.c Bsp_Usart.c Bsp_Adc.c Bsp_Lcd.c Bsp_IIC.c Bsp_Spi.c
  group Middle
    ../Middle/: Mid_Gpio.c Mid_Tim.c Mid_Key.c Mid_Usart.c Mid_Adc.c Mid_Lcd.c Mid_Ascii.c Mid_IIC.c Mid_Spi.c
  group App
    ../App/: App_Gpio.c App_All.c App_Tim.c App_Key.c App_Usart.c App_Lcd.c App_IIC.c App_Spi.c
  group User
    ../User/: stm32f10x_it.c main.c ReadMe.c
